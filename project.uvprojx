# Keil uVision project project.uvprojx, settings and files
target rt-thread (6210000::V6.21::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_LIBC, STM32F429xx
  c include: rt-thread\components\drivers\usb\cherryusb\class\video;board\ports\lcd;rt-thread\components\drivers\phy;packages\LVGL-v8.3.11\src\draw\nxp\pxp;rt-thread\components\drivers\usb\cherryusb\class\midi;packages\LVGL-v8.3.11\src\extra\others\monkey;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\drivers\usb\cherryusb\class\cdc;rt-thread\components\net\sal\include\socket\sys_socket;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;rt-thread\components\net\sal\include\dfs_net;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\core;rt-thread\components\drivers\spi\sfud\inc;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\LVGL-v8.3.11\src\widgets;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\sjpg;rt-thread\components\drivers\smp_call;libraries\HAL_Drivers;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.11\src\extra\widgets\animimg;rt-thread\components\drivers\usb\cherryusb\class\msc;rt-thread\components\drivers\sdio\sdhci\include;packages\LVGL-v8.3.11\src\extra\libs\rlottie;rt-thread\components\finsh;packages\LVGL-v8.3.11\src\extra\widgets\win;rt-thread\components\drivers\usb\cherryusb\common;applications;packages\LVGL-v8.3.11\src\extra\others\imgfont;rt-thread\components\libc\compilers\common\include;rt-thread\components\dfs\dfs_v1\filesystems\romfs;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\extra\widgets\list;packages\LVGL-v8.3.11\src\extra\widgets\meter;packages\wavplayer-latest;board\ports;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\font;packages\optparse-latest;packages\LVGL-v8.3.11\src\extra\widgets\menu;rt-thread\components\drivers\usb\cherryusb;packages\LVGL-v8.3.11\src\extra\themes\default;packages\LVGL-v8.3.11\src\extra\widgets\span;board\ports\audio;rt-thread\components\drivers\usb\cherryusb\class\vendor\serial;packages\LVGL-v8.3.11\src\draw\sdl;rt-thread\components\dfs\dfs_v1\include;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\widgets\chart;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;libraries\HAL_Drivers\CMSIS\Include;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra\libs\png;packages\LVGL-v8.3.11\src\extra\libs\freetype;rt-thread\components\drivers\usb\cherryusb\class\adb;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\libc\posix\ipc;rt-thread\components\net\sal\impl;packages\LVGL-v8.3.11\src\draw\renesas;rt-thread\include;packages\LVGL-v8.3.11\src\extra\others;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\draw\nxp\vglite;rt-thread\components\drivers\spi;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\LVGL-v8.3.11\src\draw;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\drivers\usb\cherryusb\class\vendor\net;packages\LVGL-v8.3.11\src\extra\themes;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\lwip\port;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\draw\sw;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\gif;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\LVGL-v8.3.11\src\extra\others\msg;rt-thread\components\drivers\include;rt-thread\components\drivers\usb\cherryusb\class\vendor\wifi;rt-thread\components\net\sal\include;rt-thread\components\drivers\usb\cherryusb\class\audio;packages\LVGL-v8.3.11\src\extra\widgets;.;board\ports\LVGL;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src\draw\arm2d;libraries\HAL_Drivers\drivers\config;packages\LVGL-v8.3.11\src\extra\libs\bmp;packages\LVGL-v8.3.11\src\misc;packages\wavplayer-latest\inc;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src;board\ports\CherryUSB;rt-thread\libcpu\arm\cortex-m4;board\ports\LVGL\demo;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;rt-thread\components\drivers\usb\cherryusb\class\hub;packages\LVGL-v8.3.11\src\extra\themes\mono;rt-thread\components\drivers\usb\cherryusb\class\hid;packages\LVGL-v8.3.11\src\extra\layouts;rt-thread\libcpu\arm\common;rt-thread\components\drivers\usb\cherryusb\osal;rt-thread\components\drivers\audio;board;packages\LVGL-v8.3.11\src\extra\widgets\calendar;rt-thread\components\net\netdev\include;rt-thread\components\drivers\usb\cherryusb\core;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\themes\basic;rt-thread\components\drivers\usb\cherryusb\class\dfu;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\env_support\rt-thread;board\ports\CherryUSB\demo;packages\LVGL-v8.3.11\src\extra\others\snapshot;rt-thread\components\drivers\usb\cherryusb\class\wireless;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\src\extra\layouts\flex;packages\LVGL-v8.3.11\src\draw\swm341_dma2d
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: mnt.c main.c
  group CherryUSB
    rt-thread/components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usb_msh.c
    rt-thread/components/drivers/usb/cherryusb/class/hub/: usbh_hub.c
    rt-thread/components/drivers/usb/cherryusb/port/dwc2/: usb_glue_gd.c usb_hc_dwc2.c usb_dc_dwc2.c
    rt-thread/components/drivers/usb/cherryusb/core/: usbh_core.c usbd_core.c
    rt-thread/components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    rt-thread/components/drivers/usb/cherryusb/class/msc/: usbd_msc.c
    rt-thread/components/drivers/usb/cherryusb/class/hid/: usbh_hid.c
    rt-thread/components/drivers/usb/cherryusb/class/cdc/: usbd_cdc_acm.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    rt-thread/components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    rt-thread/components/drivers/block/partitions/: dfs.c efi.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/CherryUSB/demo/: cdc_acm_multi_template.c cdc_acm_template.c msc_ram_template.c usbh_hid_template.c usbh_standard_hid.c
    board/ports/CherryUSB/: usb_demo.c usb_low.c
    board/ports/LVGL/demo/: lv_demo.c
    board/ports/LVGL/: lv_port_disp.c lv_port_indev.c mouse_cursor_icon.c
    board/ports/audio/: drv_sound.c
    board/ports/lcd/: drv_lcd.c
    board/ports/: phy_reset.c romfs.c sdcard_port.c spi_flash_init.c
    libraries/HAL_Drivers/drivers/: drv_eth.c drv_gpio.c drv_pwm.c drv_sdio.c drv_sdram.c drv_spi.c drv_tim.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c msh_file.c msh_parse.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c rt_vsscanf.c kerrno.c rt_vsnprintf_tiny.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_sai.c stm32f4xx_hal_gpio.c stm32f4xx_hal_crc.c stm32f4xx_hal_qspi.c stm32f4xx_hal_tim.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_sd.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2s.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_cryp_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rng.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group LVGL
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_indev.c lv_hal_disp.c lv_hal_tick.c
    packages/LVGL-v8.3.11/src/misc/: lv_ll.c lv_style_gen.c lv_math.c lv_timer.c lv_gc.c lv_anim.c lv_tlsf.c lv_bidi.c lv_anim_timeline.c lv_printf.c lv_txt_ap.c lv_fs.c lv_mem.c lv_async.c lv_templ.c lv_color.c lv_txt.c lv_log.c lv_utils.c lv_area.c lv_lru.c lv_style.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/widgets/: lv_slider.c lv_label.c lv_img.c lv_objx_templ.c lv_line.c lv_btn.c lv_btnmatrix.c lv_switch.c lv_table.c lv_canvas.c lv_roller.c lv_checkbox.c lv_bar.c lv_dropdown.c lv_arc.c lv_textarea.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_dither.c lv_draw_sw_layer.c lv_draw_sw_arc.c lv_draw_sw_line.c lv_draw_sw_gradient.c lv_draw_sw_rect.c lv_draw_sw_polygon.c lv_draw_sw_letter.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/font/: lv_font_montserrat_24.c lv_font_montserrat_16.c lv_font_montserrat_34.c lv_font_montserrat_38.c lv_font_montserrat_18.c lv_font_montserrat_12_subpx.c lv_font_montserrat_20.c lv_font.c lv_font_montserrat_26.c lv_font_loader.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_32.c lv_font_montserrat_40.c lv_font_montserrat_28.c lv_font_montserrat_10.c lv_font_montserrat_28_compressed.c lv_font_montserrat_36.c lv_font_montserrat_46.c lv_font_montserrat_22.c lv_font_fmt_txt.c lv_font_montserrat_42.c lv_font_montserrat_30.c lv_font_montserrat_48.c lv_font_montserrat_44.c lv_font_montserrat_8.c lv_font_unscii_16.c lv_font_montserrat_12.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_montserrat_14.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_label.c lv_img_decoder.c lv_img_cache.c lv_draw_line.c lv_draw_layer.c lv_draw.c lv_draw_img.c lv_draw_rect.c lv_draw_arc.c lv_draw_transform.c lv_img_buf.c lv_draw_mask.c lv_draw_triangle.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_rect.c lv_draw_vglite_line.c lv_vglite_utils.c lv_draw_vglite_blend.c lv_vglite_buf.c lv_draw_vglite.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_bg.c lv_draw_sdl.c lv_draw_sdl_line.c lv_draw_sdl_texture_cache.c lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_polygon.c lv_draw_sdl_stack_blur.c lv_draw_sdl_arc.c lv_draw_sdl_rect.c lv_draw_sdl_img.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/core/: lv_event.c lv_obj_draw.c lv_obj_scroll.c lv_theme.c lv_disp.c lv_obj_class.c lv_obj_style_gen.c lv_obj_pos.c lv_group.c lv_indev_scroll.c lv_obj_style.c lv_obj.c lv_indev.c lv_refr.c lv_obj_tree.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_stdio.c lv_fs_littlefs.c lv_fs_win32.c lv_fs_posix.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
  group LVGL-port
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group optparse
    packages/optparse-latest/: optparse.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group wavplayer
    packages/wavplayer-latest/src/: wavplayer_cmd.c wavhdr.c wavplayer.c
